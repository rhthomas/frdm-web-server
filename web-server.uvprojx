# Keil uVision project web-server.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MKW41Z256xxx4 NXP
  pack: Keil.Kinetis_KWxx_DFP.1.7.0
  cpu: IRAM(0x1FFF8000,0x00010000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: web-server
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x10000
