# Keil uVision project webserverBlinky.uvprojx, settings and files
target webserverBlinky (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MKW41Z512xxx4 NXP
  pack: Keil.Kinetis_KWxx_DFP.1.7.0
  cpu: CPUTYPE("Cortex-M0+")
  output: webserverBlinky
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DTARGET_KSDK2_MCUS -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD --preinclude=mbed_config.h -D__CORTEX_M0PLUS -D__ASSERT_MSG -DTARGET_RELEASE --no_rtti -DDEVICE_PORTINOUT=1 -DTARGET_FF_ARDUINO -c -DTARGET_M0P -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 --split_sections -DTARGET_LIKE_CORTEX_M0 -DDEVICE_ANALOGIN=1 -DDEVICE_PORTIN=1 -DTARGET_KW41Z -DTARGET_CORTEX_M -DARM_MATH_CM0PLUS -DTARGET_Freescale -DDEVICE_I2C=1 -DTARGET_MCUXpresso_MCUS -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED -D__CMSIS_RTOS --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu -DDEVICE_TRNG=1 --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DTARGET_FRDM -DMBED_BUILD_TIMESTAMP=1511215468.54 -DDEVICE_SERIAL=1 -DTARGET_CORTEX -DDEVICE_I2CSLAVE=1 -DFSL_RTOS_MBED --cpu=Cortex-M0 -D__MBED_CMSIS_RTOS_CM -DCPU_MKW41Z512VHT4
  c include: .; PPP-Blinky; SHA1; mbed/.; mbed/TARGET_KW41Z; mbed/TARGET_KW41Z/TARGET_Freescale; mbed/TARGET_KW41Z/TARGET_Freescale/TARGET_MCUXpresso_MCUS; mbed/TARGET_KW41Z/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_KW41Z; mbed/TARGET_KW41Z/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_KW41Z/TARGET_FRDM; mbed/TARGET_KW41Z/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_KW41Z/device; mbed/TARGET_KW41Z/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_KW41Z/drivers; mbed/TARGET_KW41Z/TARGET_Freescale/TARGET_MCUXpresso_MCUS/api; mbed/TARGET_KW41Z/TOOLCHAIN_ARM_STD; mbed/drivers; mbed/hal; mbed/platform
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-DCPU_MKW41Z512VHT4,-D__CORTEX_M0PLUS,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS,-DFSL_RTOS_MBED,-DARM_MATH_CM0PLUS
  asm include: .; PPP-Blinky; SHA1; mbed/.; mbed/TARGET_KW41Z; mbed/TARGET_KW41Z/TARGET_Freescale; mbed/TARGET_KW41Z/TARGET_Freescale/TARGET_MCUXpresso_MCUS; mbed/TARGET_KW41Z/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_KW41Z; mbed/TARGET_KW41Z/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_KW41Z/TARGET_FRDM; mbed/TARGET_KW41Z/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_KW41Z/device; mbed/TARGET_KW41Z/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_KW41Z/drivers; mbed/TARGET_KW41Z/TARGET_Freescale/TARGET_MCUXpresso_MCUS/api; mbed/TARGET_KW41Z/TOOLCHAIN_ARM_STD; mbed/drivers; mbed/hal; mbed/platform;
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_KW41Z/TOOLCHAIN_ARM_STD/MKW41Z512xxx4.sct
  link misc: --show_full_path
  group mbed
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h Serial.h SerialBase.h SPI.h SPISlave.h Ticker.h Timeout.h Timer.h TimerEvent.h UARTSerial.h
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h Driver_Common.h Driver_Storage.h emac_api.h ethernet_api.h flash_api.h flash_data.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/TARGET_KW41Z/TOOLCHAIN_ARM_STD/: analogin_api.o analogout_api.o dma_api.o flash_api.o fsl_adc16.o fsl_clock.o fsl_clock_config.o fsl_cmp.o fsl_cmt.o fsl_common.o fsl_cop.o fsl_dac.o fsl_dcdc.o fsl_dmamux.o fsl_dspi.o fsl_dspi_edma.o fsl_edma.o fsl_flash.o fsl_gpio.o fsl_i2c.o fsl_i2c_edma.o fsl_llwu.o fsl_lptmr.o fsl_lpuart.o fsl_lpuart_edma.o fsl_ltc.o fsl_ltc_edma.o fsl_pit.o fsl_pmc.o fsl_rcm.o fsl_rtc.o fsl_sim.o fsl_smc.o fsl_tpm.o fsl_trng.o fsl_tsi_v4.o fsl_vref.o gpio_api.o gpio_irq_api.o i2c_api.o lp_ticker.o mbed.ar mbed_board.o mbed_overrides.o mbed_retarget.o mbed_sdk_boot.o PeripheralPins.o pinmap.o port_api.o pwmout_api.o rtc_api.o serial_api.o sleep.o spi_api.o startup_MKW41Z4.o system_MKW41Z4.o trng_api.o us_ticker.o
    mbed/TARGET_KW41Z/: arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h core_armv8mbl.h core_armv8mml.h core_ca.h core_cm0.h core_cm0plus.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_cmSecureAccess.h core_sc000.h core_sc300.h tz_context.h
    mbed/platform/: ATCmdParser.h Callback.h CallChain.h CircularBuffer.h critical.h CriticalSectionLock.h CThunk.h DeepSleepLock.h DirHandle.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.h mbed_application.h mbed_assert.h mbed_critical.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_mktime.h mbed_poll.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_toolchain.h mbed_wait_api.h NonCopyable.h platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h sleep.h Stream.h toolchain.h Transaction.h wait_api.h
    mbed/TARGET_KW41Z/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_KW41Z/device/: cmsis.h cmsis_nvic.h fsl_device_registers.h MKW41Z4.h MKW41Z4_features.h system_MKW41Z4.h
    mbed/TARGET_KW41Z/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_KW41Z/TARGET_FRDM/: device.h fsl_clock_config.h PeripheralNames.h PinNames.h
    mbed/TARGET_KW41Z/TARGET_Freescale/TARGET_MCUXpresso_MCUS/api/: dma_api_hal.h gpio_object.h objects.h PeripheralPins.h PortNames.h
    mbed/TARGET_KW41Z/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_KW41Z/drivers/: fsl_adc16.h fsl_clock.h fsl_cmp.h fsl_cmt.h fsl_common.h fsl_cop.h fsl_dac.h fsl_dcdc.h fsl_dmamux.h fsl_dspi.h fsl_dspi_edma.h fsl_edma.h fsl_flash.h fsl_gpio.h fsl_i2c.h fsl_i2c_edma.h fsl_llwu.h fsl_lptmr.h fsl_lpuart.h fsl_lpuart_edma.h fsl_ltc.h fsl_ltc_edma.h fsl_pit.h fsl_pmc.h fsl_port.h fsl_rcm.h fsl_rtc.h fsl_sim.h fsl_smc.h fsl_tpm.h fsl_trng.h fsl_tsi_v4.h fsl_vref.h
    mbed/: mbed.h
    mbed/TARGET_KW41Z/TARGET_Freescale/: mbed_rtx.h
    mbed/TARGET_KW41Z/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_KW41Z/: peripheral_clock_defines.h
  group PPP-Blinky
    PPP-Blinky/: ppp-blinky.cpp ppp-blinky.h
  group SHA1
    SHA1/: sha1.cpp sha1.h
  group webserverBlinky
    ./: main.cpp mbed_config.h
